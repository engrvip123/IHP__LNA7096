v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {iopin.sym} 90 -80 0 0 {name=p1 lab=n1}
C {iopin.sym} 90 -40 0 0 {name=p2 lab=n2}
C {iopin.sym} 90 10 0 0 {name=p3 lab=gnd}
