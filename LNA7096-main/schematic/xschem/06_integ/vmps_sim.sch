v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 14370 -6490 15170 -6090 {flags=graph
y2=1.442
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 13"
node="s2d_outn
ppf_inn"
y1=0.932}
B 2 14360 -6920 15160 -6520 {flags=graph
y1=0.31
y2=0.71
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="inpq
innq
inn
inp
ppf_inp
ppf_inn"
color="7 11 5 12 9 18"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 14370 -6090 15170 -5690 {flags=graph
y1=1.046
y2=1.316
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 13"
node="s2d_outp

ppf_inp"}
B 2 14360 -7350 15160 -6950 {flags=graph
y1=0.69
y2=0.83
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 12 7"
node="inp

s2d_outn
s2d_outp"}
B 2 14355 -7765 15155 -7365 {flags=graph
y1=-0.0046
y2=0.71
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 7 8 18"
node="innq
inn
inpq
inp"}
B 2 15200 -6920 16000 -6520 {flags=graph
y1=0.32
y2=0.35
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=ppf_inn
color=9
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 15200 -6480 16000 -6080 {flags=graph
y1=-0.011
y2=0.71
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="diff_out_tran
inp"
color="9 18"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 15200 -7330 16000 -6930 {flags=graph
y1=0.575
y2=0.59
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=ppf_inp
color=9
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 12270 -6050 12600 -5880 {flags=graph
y2=0.83
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 18"
node="s2d_outp
s2d_outn"
y1=0.77}
B 2 12630 -6050 12960 -5880 {flags=graph
y2=0.59
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 18"
node="ppf_inp
ppf_inn"
y1=0.32}
B 2 12630 -5860 12960 -5690 {flags=graph
y2=0.71
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 18"
node="inp
inn"
y1=0.31}
B 2 13980 -6400 14310 -6230 {flags=graph
y2=0.56
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 15 9"
node="outp
outn
diff_out_tran"
y1=-0.011}
B 2 12280 -5860 12610 -5690 {flags=graph
y2=0.46
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="4 18"
node="inpq
innq"
y1=0.32}
B 2 13540 -6350 13870 -6180 {flags=graph
y2=0.92
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
y1=0.54
color="9 7 12 18"
node="x1.inp_a
x1.inn_a

x1.inn_b
x1.inp_b"}
B 2 13540 -6180 13870 -6010 {flags=graph
y2=0.97
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=1e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
y1=0.54
color="9 7 12 18"
node="x2.inp_a
x2.inn_a

x2.inn_b
x2.inp_b"}
N 13500 -6770 13500 -6730 {lab=GND}
N 13500 -6880 13500 -6830 {lab=vdd}
N 13910 -6370 13910 -6330 {lab=GND}
N 13290 -6620 13760 -6620 {lab=ctrln_i}
N 13290 -6620 13290 -6560 {lab=ctrln_i}
N 13150 -6640 13760 -6640 {lab=ctrlp_i}
N 13150 -6640 13150 -6560 {lab=ctrlp_i}
N 13430 -6560 13760 -6560 {lab=inp}
N 13500 -6540 13760 -6540 {lab=inn}
N 13500 -6880 13910 -6880 {lab=vdd}
N 13910 -6880 13910 -6710 {lab=vdd}
N 13590 -6770 13590 -6730 {lab=GND}
N 13840 -6850 13840 -6710 {lab=bias_vga}
N 13590 -6850 13840 -6850 {lab=bias_vga}
N 13590 -6850 13590 -6830 {lab=bias_vga}
N 13910 -6450 13910 -6430 {lab=vss}
N 14060 -6600 14130 -6600 {lab=outp}
N 14060 -6560 14130 -6560 {lab=outn}
N 13430 -6560 13430 -6450 {lab=inp}
N 13500 -6540 13500 -6450 {lab=inn}
N 13430 -6390 13430 -6380 {lab=#net1}
N 13500 -6390 13500 -6380 {lab=#net2}
N 13290 -6500 13290 -6490 {lab=GND}
N 13150 -6500 13150 -6490 {lab=GND}
N 13935 -5670 13935 -5650 {lab=vss}
N 14085 -5820 14155 -5820 {lab=outp}
N 14085 -5780 14155 -5780 {lab=outn}
N 13935 -5960 13935 -5925 {lab=vdd}
N 13865 -5955 13865 -5925 {lab=bias_vga}
N 13470 -5600 13470 -5590 {lab=#net3}
N 13540 -5600 13540 -5590 {lab=#net4}
N 13540 -5760 13785 -5760 {lab=innq}
N 13470 -5780 13785 -5780 {lab=inpq}
N 13540 -5760 13540 -5660 {lab=innq}
N 13470 -5780 13470 -5660 {lab=inpq}
N 13310 -5730 13310 -5720 {lab=GND}
N 13170 -5730 13170 -5720 {lab=GND}
N 13170 -5860 13785 -5860 {lab=ctrlp_q}
N 13310 -5840 13785 -5840 {lab=ctrln_q}
N 13170 -5860 13170 -5790 {lab=ctrlp_q}
N 13310 -5840 13310 -5790 {lab=ctrln_q}
N 13170 -6290 13220 -6290 {lab=inp}
N 13170 -6260 13220 -6260 {lab=inn}
N 13170 -6200 13220 -6200 {lab=inpq}
N 13170 -6170 13220 -6170 {lab=innq}
N 13020 -6140 13020 -6120 {lab=vss}
N 12330 -6350 12330 -6310 {lab=vdd}
N 12330 -6150 12330 -6110 {lab=vss}
N 12480 -6210 12480 -6140 {lab=s2d_outn}
N 12080 -6070 12080 -6030 {lab=GND}
N 12080 -6230 12080 -6120 {lab=inp}
N 12080 -6230 12180 -6230 {lab=inp}
N 12760 -6260 12870 -6260 {lab=ppf_inp}
N 12220 -6340 12220 -6310 {lab=#net5}
N 12480 -6260 12640 -6260 {lab=s2d_outp}
N 12480 -6140 12640 -6140 {lab=s2d_outn}
N 12760 -6140 12870 -6140 {lab=ppf_inn}
N 12870 -6200 12870 -6140 {lab=ppf_inn}
N 12700 -6330 12700 -6300 {lab=vdd}
N 12700 -6230 12700 -6220 {lab=vss}
N 12700 -6190 12700 -6180 {lab=vdd}
N 12700 -6110 12700 -6090 {lab=vss}
C {lab_pin.sym} 13430 -6560 0 0 {name=p11 sig_type=std_logic lab=inp
}
C {gnd.sym} 13430 -6380 0 0 {name=l3 lab=GND
spice_ignore=true}
C {vsource.sym} 13430 -6420 0 1 {name=Vin_p value="DC \{CM_rf\} AC 1.0 0   SIN(\{CM_rf\} 10m \{F_signal\} 0 0 90)"  savecurrent=false
spice_ignore=true}
C {gnd.sym} 13500 -6740 0 0 {name=l4 lab=GND
}
C {vsource.sym} 13500 -6800 0 0 {name=V1 value=1.2 savecurrent=false
}
C {lab_pin.sym} 13500 -6870 0 0 {name=p13 sig_type=std_logic lab=vdd

}
C {gnd.sym} 13910 -6340 0 0 {name=l5 lab=GND
}
C {vsource.sym} 13910 -6400 0 0 {name=V2 value=0 savecurrent=false
}
C {lab_pin.sym} 13910 -6440 0 1 {name=p14 sig_type=std_logic lab=vss

}
C {lab_pin.sym} 13500 -6540 0 0 {name=p15 sig_type=std_logic lab=inn
}
C {gnd.sym} 13500 -6380 0 0 {name=l6 lab=GND
spice_ignore=true}
C {vsource.sym} 13500 -6420 0 0 {name=Vin_n value="DC \{CM_rf\} AC 1.0 180 SIN(\{CM_rf\} 10m \{F_signal\} 0 0 270)"  savecurrent=false
spice_ignore=true}
C {devices/code_shown.sym} 13980 -5530 0 0 {name=MODEL1 only_toplevel=true
format="tcleval( @value )"
value="
.lib $::SG13G2_MODELS/cornerCAP.lib cap_typ
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.include /home/ic_design_trg/pdk/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice
"}
C {gnd.sym} 13150 -6490 0 0 {name=l8 lab=GND
}
C {vsource.sym} 13150 -6530 0 0 {name=V5 value="ctrlp_i" savecurrent=false
}
C {lab_pin.sym} 13150 -6625 0 0 {name=p17 sig_type=std_logic lab=ctrlp_i

}
C {gnd.sym} 13290 -6490 0 0 {name=l9 lab=GND
}
C {vsource.sym} 13290 -6530 0 0 {name=V6 value="ctrln_i" savecurrent=false
}
C {lab_pin.sym} 13290 -6570 0 0 {name=p18 sig_type=std_logic lab=ctrln_i

}
C {devices/launcher.sym} 13360 -6100 0 0 {name=h3
descr="OP annotate" 
tclcommand="xschem annotate_op"
}
C {launcher.sym} 13360 -6060 0 0 {name=h4
descr="load TRAN"
tclcommand="xschem raw_read $netlist_dir/vmps.raw tran"
}
C {launcher.sym} 13360 -6150 0 0 {name=h1
descr="load AC"
tclcommand="xschem raw_read $netlist_dir/vga_sch_TB.raw  ac"
}
C {vmps/vga/vga_sch_I.sym} 13910 -6580 0 0 {name=x1
}
C {gnd.sym} 13590 -6740 0 0 {name=l1 lab=GND
}
C {vsource.sym} 13590 -6800 0 0 {name=V3 value=0.6 savecurrent=false
}
C {lab_pin.sym} 13600 -6850 0 0 {name=p1 sig_type=std_logic lab=bias_vga


}
C {lab_pin.sym} 14130 -6600 0 1 {name=p2 sig_type=std_logic lab=outp

}
C {lab_pin.sym} 14130 -6560 0 1 {name=p3 sig_type=std_logic lab=outn

}
C {lab_pin.sym} 13935 -5660 0 1 {name=p4 sig_type=std_logic lab=vss

}
C {vmps/vga/vga_sch_Q.sym} 13935 -5800 0 0 {name=x2
}
C {lab_pin.sym} 14155 -5820 0 1 {name=p5 sig_type=std_logic lab=outp

}
C {lab_pin.sym} 14155 -5780 0 1 {name=p6 sig_type=std_logic lab=outn

}
C {lab_pin.sym} 13935 -5950 0 1 {name=p7 sig_type=std_logic lab=vdd

}
C {lab_pin.sym} 13865 -5950 0 0 {name=p8 sig_type=std_logic lab=bias_vga


}
C {gnd.sym} 13470 -5590 0 0 {name=l7 lab=GND
spice_ignore=true}
C {vsource.sym} 13470 -5630 0 1 {name=Vin_p1 value="DC \{CM_rf\} AC 1.0 90   SIN(\{CM_rf\} 10m \{F_signal\} 0 0 0)"  savecurrent=false
spice_ignore=true}
C {gnd.sym} 13540 -5590 0 0 {name=l10 lab=GND
spice_ignore=true}
C {vsource.sym} 13540 -5630 0 0 {name=Vin_n1 value="DC \{CM_rf\} AC 1.0 270 SIN(\{CM_rf\} 10m \{F_signal\} 0 0 180)"  savecurrent=false
spice_ignore=true}
C {lab_pin.sym} 13470 -5780 0 0 {name=p12 sig_type=std_logic lab=inpq
}
C {lab_pin.sym} 13540 -5730 0 0 {name=p16 sig_type=std_logic lab=innq
}
C {gnd.sym} 13170 -5720 0 0 {name=l2 lab=GND
}
C {vsource.sym} 13170 -5760 0 0 {name=V7a value="ctrlp_q"  savecurrent=false
}
C {lab_pin.sym} 13170 -5815 0 0 {name=p19 sig_type=std_logic lab=ctrlp_q

}
C {gnd.sym} 13310 -5720 0 0 {name=l11 lab=GND
}
C {vsource.sym} 13310 -5760 0 0 {name=V8a value="ctrln_q" savecurrent=false
}
C {lab_pin.sym} 13310 -5800 0 0 {name=p20 sig_type=std_logic lab=ctrln_q

}
C {vmps/iq_ppf/ppf01.sym} 13020 -6230 0 0 {name=x3
}
C {lab_pin.sym} 13220 -6290 0 1 {name=p9 sig_type=std_logic lab=inp
}
C {lab_pin.sym} 13220 -6260 0 1 {name=p10 sig_type=std_logic lab=inn
}
C {lab_pin.sym} 13220 -6200 0 1 {name=p21 sig_type=std_logic lab=inpq
}
C {lab_pin.sym} 13220 -6170 0 1 {name=p22 sig_type=std_logic lab=innq
}
C {lab_pin.sym} 13020 -6130 0 1 {name=p23 sig_type=std_logic lab=vss

}
C {vmps/s2d/s2d.sym} 12330 -6230 0 0 {name=x4}
C {lab_pin.sym} 12330 -6340 0 1 {name=p24 sig_type=std_logic lab=vdd

}
C {lab_pin.sym} 12330 -6140 0 1 {name=p25 sig_type=std_logic lab=vss

}
C {lab_pin.sym} 12080 -6160 0 0 {name=p26 sig_type=std_logic lab=inp
}
C {gnd.sym} 12080 -6040 0 0 {name=l12 lab=GND
}
C {vsource.sym} 12080 -6100 0 0 {name=V10 value="SIN(0.7 10m \{Freq\} 0 0 0) AC 1"  savecurrent=false
}
C {lab_pin.sym} 12500 -6260 0 1 {name=p27 sig_type=std_logic lab=s2d_outp
}
C {lab_pin.sym} 12530 -6140 0 1 {name=p28 sig_type=std_logic lab=s2d_outn
}
C {devices/code_shown.sym} 10490 -7740 0 0 {name=Single_AC_TRAN_run only_toplevel=true 
value="
.include /home/ic_design_trg/lna_ihp/xschem/vmps/integ/simulation/vmps.save
.temp=27

.param ctrlp_i=0.9 ctrln_i=0.3
.param ctrlp_q=0.6 ctrln_q=0.6

.param VDD_val = 1.2
.param CM_rf = 0.6
.param freq = 1.17645G

.control
  * --- 0. Setup and Initialization ---
  save all  v(x1.inp_a) v(x1.inn_a)
  * Unset appendwrite initially to ensure the first write creates a fresh file [1]
  unset appendwrite

  * --- 1. Operating Point Analysis (OP) ---
  op
  remzerovec
  * On this first write, 'appendwrite' is unset, so this CREATES the file [1]
  write vmps.raw all
  
  * Set appendwrite so ALL subsequent writes append as new plots to this file [1]
  set appendwrite
  
  * Free memory (optional but recommended)
  destroy $curplot


  * --- 2. AC Simulation ---
  * Sweep frequency linear 200 points around center freq, or a wider range
  ac lin 200 0.1G 2.5G

  * A. Calculate Magnitude (dB) and Phase (Degrees)
  *    db() calculates 20*log10(mag) 
  *    ph() calculates phase in radians, convert to deg
  let mag_outp = db(v(s2d_outp))
  let mag_outn = db(v(s2d_outn))
  let ph_outp = ph(v(s2d_outp)) * 180 / PI
  let ph_outn = ph(v(s2d_outn)) * 180 / PI

  let phase_outp_unwrapped = cph(v(outp)) * 180 / PI
  let phase_outn_unwrapped = cph(v(outn)) * 180 / PI

  * B. Calculate Imbalance
  *    Amplitude Imbalance: Difference in dB
  let amp_imbal_db = mag_outp - mag_outn

  *    Phase Difference: (Phase_P - Phase_N)
  *    Phase Imbalance: Deviation from ideal 180 degrees
  let phase_diff = ph_outp - ph_outn
  let phase_imbal_deg = abs(abs(phase_diff) - 180)

  * C. Measure at Fundamental Frequency (1.17645 GHz)
  *    Using 'meas ac'
  meas ac Mag_P_dB find mag_outp at=1.17645e9
  meas ac Mag_N_dB find mag_outn at=1.17645e9
  meas ac Amp_Imbal_dB find amp_imbal_db at=1.17645e9

  meas ac Phase_P_Deg find ph_outp at=1.17645e9
  meas ac Phase_N_Deg find ph_outn at=1.17645e9
  meas ac Phase_Diff_Deg find phase_diff at=1.17645e9
  meas ac Phase_Imbal_Deg find phase_imbal_deg at=1.17645e9

  * D. Print Results
  print Amp_Imbal_dB Phase_Diff_Deg Phase_Imbal_Deg

  * E. Save AC results to raw file
  * Appends strictly as an independent AC plot block [2]
  write vmps.raw inp s2d_outp s2d_outn ppf_inp  ppf_inn inp inn inpq innq outp outn mag_outp mag_outn amp_imbal_db ph_outp ph_outn phase_diff phase_outp_unwrapped phase_outn_unwrapped
  
  * Free memory
  destroy $curplot


  * --- 3. Transient Simulation ---
  tran 0.01n 10n

 let diff_out_tran = v(outp) - v(outn)

  remzerovec
  
  * Save TRAN vectors to the same raw file
  * Appends strictly as an independent TRAN plot block [2]
  write vmps.raw all diff_out_tran v(x1.inp_a) v(x1.inn_a)

  * Free memory
  destroy $curplot


.endc
"


spice_ignore=true}
C {vmps/sor_foll/sor_foll.sym} 12710 -6260 0 0 {name=x5}
C {vmps/sor_foll/sor_foll.sym} 12710 -6140 0 0 {name=x6}
C {lab_pin.sym} 12780 -6260 0 1 {name=p29 sig_type=std_logic lab=ppf_inp
}
C {lab_pin.sym} 12790 -6140 0 1 {name=p30 sig_type=std_logic lab=ppf_inn
}
C {lab_pin.sym} 12700 -6330 0 1 {name=p31 sig_type=std_logic lab=vdd

}
C {lab_pin.sym} 12700 -6220 0 1 {name=p32 sig_type=std_logic lab=vss

}
C {lab_pin.sym} 12700 -6190 0 1 {name=p33 sig_type=std_logic lab=vdd

}
C {lab_pin.sym} 12700 -6100 0 1 {name=p34 sig_type=std_logic lab=vss

}
C {vmps/iq_ppf/ppf.sym} 12920 -6420 0 0 {name=x7
spice_ignore=true}
C {devices/code_shown.sym} 9460 -7730 0 0 {name=64_step_ac_run_plot only_toplevel=true 
value="
.include /home/ic_design_trg/lna_ihp/xschem/vmps/integ/simulation/vmps.save
.temp=27

.param ctrlp_i=0.9 ctrln_i=0.3
.param ctrlp_q=0.6 ctrln_q=0.6

.param VDD_val = 1.2
.param CM_rf = 0.6
.param freq = 1.17645G



.control
  * --- 0. Setup and Initialization ---
  * Save the required nodes including the input node 'inp' to conserve memory
  save v(outp) v(outn) v(inp)
  
  * Unset appendwrite initially to ensure we create a fresh file
  unset appendwrite

  * --- 1. Define Phase Angle and Control Vectors ---
  compose theta_vals start=0 stop=360 step=5.625
  let rad_vec = theta_vals * PI / 180

  * Define Constants
  let v_cm = 0.6
  let v_max = 0.3
  let gamma = 1.2

  * --- 2. PRE-DISTORTION SETTING ---
  let cos_w = cos(rad_vec)
  let sin_w = sin(rad_vec)

  * Use 'gt' and 'lt' to emulate sgn()
  let sgn_cos = (cos_w gt 0) - (cos_w lt 0)
  let sgn_sin = (sin_w gt 0) - (sin_w lt 0)

  * Apply Power-Law Mapping
  let i_corr = sgn_cos * (abs(cos_w)^gamma)
  let q_corr = sgn_sin * (abs(sin_w)^gamma)

  * Pre-calculate 4-Quadrant Control Voltages
  let pi_p_vec = v_cm + v_max * i_corr
  let pi_n_vec = v_cm - v_max * i_corr
  let pq_p_vec = v_cm + v_max * q_corr
  let pq_n_vec = v_cm - v_max * q_corr

  * --- 3. Initialize Loop ---
  let n_runs = length(theta_vals)
  let run_idx = 0
  
  * Capture the start plot (constants) to retrieve vectors later
  set start_plot = $curplot

  * [UPDATED] Create CSV File Header including Gain_dB
  echo theta,ctrlp_i,ctrln_i,ctrlp_q,ctrln_q,Mag_Diff_dB,Phase_Diff_Deg,Gain_dB > vmps_sweep.csv

  * --- 4. Execution Loop ---
  dowhile run_idx < n_runs

    * A. Retrieve calculated DC voltages from the start plot
    let pip_act = \{$start_plot\}.pi_p_vec[run_idx]
    let pin_act = \{$start_plot\}.pi_n_vec[run_idx]
    let pqp_act = \{$start_plot\}.pq_p_vec[run_idx]
    let pqn_act = \{$start_plot\}.pq_n_vec[run_idx]
    let t_act = \{$start_plot\}.theta_vals[run_idx]

    * B. Apply Bias
    alter V5 dc = $&pip_act
    alter V6 dc = $&pin_act
    alter V7a dc = $&pqp_act
    alter V8a dc = $&pqn_act

    * ---------------------------------------------------
    * C. AC Simulation
    * ---------------------------------------------------
    ac lin 200 0.1G 2.5G

    * 1. Calculate Differential Voltage
    let vdiff_out = v(outp) - v(outn)
    
    * 2. Calculate Differential Magnitude (dB) and Phase (Degrees)
    let mag_diff = db(vdiff_out)
    let ph_diff = cph(vdiff_out) * 180 / PI

    * 3. [NEW] Calculate Gain between input 'inp' and differential output
    let gain_linear = vdiff_out / v(inp)
    let gain_db_vec = db(gain_linear)

    * 4. Measure specifically at Fundamental Frequency (1.17645 GHz)
    meas ac Mag_Diff_dB find mag_diff at=1.17645e9
    meas ac Phase_Diff_Deg find ph_diff at=1.17645e9
    meas ac Gain_dB find gain_db_vec at=1.17645e9

    * 5. [UPDATED] Write Results and Control Voltages to CSV
    echo $&t_act,$&pip_act,$&pin_act,$&pqp_act,$&pqn_act,$&Mag_Diff_dB,$&Phase_Diff_Deg,$&Gain_dB >> vmps_sweep.csv

    * 6. Save AC results to RAW file (appending sequentially)
    if run_idx = 0
       * Explicitly save the needed generated vectors including the newly calculated gain
       write vmps_ac.raw v(outp) v(outn) v(inp) vdiff_out mag_diff ph_diff gain_db_vec
       set appendwrite
    else
       write vmps_ac.raw v(outp) v(outn) v(inp) vdiff_out mag_diff ph_diff gain_db_vec
    end
    
    * Free memory
    destroy $curplot

    let run_idx = run_idx + 1
  end
.endc
"


}
